# IAR project PORT_Driver.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xC ST STM32F401xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PORT_Driver.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group (top)
    ./: bluetooth.c bluetooth.h common_macros.h gps.c gps.h gps_commands.h i2c_driver.c i2c_driver.h i2c_registers.h main.c port.c port.h port_registers.h Qmc5883l.c Qmc5883l.h std_types.h uart_driver.c uart_driver.h uart_registers.h
